## board/talenuse/mx6dsysd/Kconfig
```kconfig
if TARGET_MX6DSYSD

config SYS_BOARD
	default "mx6dsysd"

config SYS_VENDOR
	default "talenuse"

config SYS_CONFIG_NAME
	default "mx6dsysd"

endif
```
